require optee-client-imx.inc

SRCBRANCH = "lf_4.4.y"
SRCREV = "d221676a58b305bddbf97db00395205b3038de8e"
