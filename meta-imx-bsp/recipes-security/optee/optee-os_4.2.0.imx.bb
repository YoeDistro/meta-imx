require optee-os-imx.inc

SRCBRANCH = "lf_4.2.y"
SRCREV = "732f546cfb2968fc1fc865243a4dd0129364df53"
