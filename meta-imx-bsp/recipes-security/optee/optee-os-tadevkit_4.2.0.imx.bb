require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.2.y"
SRCREV = "85626abfcacd2c45dbff4e9b2bb19fcc3d605c3d"
