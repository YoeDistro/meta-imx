require optee-os-imx.inc

SRCBRANCH = "lf_4.4.y"
SRCREV = "d86313a3462938714dd11f7989e86a596fb58c9e"
