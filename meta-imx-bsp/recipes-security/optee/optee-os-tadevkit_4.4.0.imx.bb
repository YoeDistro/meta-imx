require optee-os-tadevkit-imx.inc

SRCBRANCH = "lf_4.4.y"
SRCREV = "${AUTOREV}"
