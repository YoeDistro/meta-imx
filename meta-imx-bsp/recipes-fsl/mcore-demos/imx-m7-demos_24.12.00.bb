# Copyright 2023-2024 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

require imx-mcore-demos.inc

LIC_FILES_CHKSUM:mx95-nxp-bsp = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837" 

SRC_URI[imx95.sha256sum] = "9733801af54b1b0cfea222d256f32be13b217262fa6720ffd9b20bfaa267583b"

COMPATIBLE_MACHINE = "(mx95-nxp-bsp)"
