require imx-gpu-viv-6-overrides.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ca53281cc0caa7e320d4945a896fb837" 

IMX_SRCREV_ABBREV = "1a38348"

SRC_URI[sha256sum] = "035eed648dbf1640ca6cdac31d9fb5e5acb7f0dbbcce0c68ff9c804b513162de"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp)"
